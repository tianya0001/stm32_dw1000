<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\L051_UWB_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>
